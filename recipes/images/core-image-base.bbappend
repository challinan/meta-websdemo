PRINC := "${@int(PRINC) + 1}"

IMAGE_INSTALL_append += " websdemo"

